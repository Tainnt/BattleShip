# Keil uVision project main.uvproj, settings and files
target smpl_GPIO_Interrupt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140LC1CN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_GPIO_Interrupt +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\Libary\CMSIS\CM0\CoreSupport;..\Libary\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\Libary\Include;..\Libary\Include\Driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../Libary/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../Libary/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../Libary/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: main.c
  group Library files
    ../Libary/Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c
